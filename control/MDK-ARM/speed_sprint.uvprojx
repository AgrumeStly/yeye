# Keil uVision project speed_sprint.uvprojx, settings and files
target SpeedSprint (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: speed_sprint +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000,BOARD_UART_ENABLE=0,MOTOR_BENCH_TARGET=1,SPEED_SPRINT_TARGET=1
  c misc: --c99
  c include: ..\Core\Inc;..\App\Car;..\App\Diagnostics;..\Drivers_Custom\Board;..\Drivers_Custom\Motor;..\Drivers_Custom\Communication;..\Drivers\cmsis;..\Drivers\stm32;..\Drivers\stdperiph\inc;..\App\Motion;..\Algorithms\Speed;..\Algorithms\Encoder;..\Drivers_Custom\Encoder
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ../Core/Src/: main.c logic_demo.c board_self_test.c speed_match_main.c motor_direct_main.c
    ../App/Car/: car.c
    ../Drivers_Custom/Communication/: protocol.c
    ../App/Motion/: speed_match.c speed_sprint.c
    ../Drivers_Custom/Motor/: straight_pwm.c motor_direct_gpio.c
  group Board
    ../Drivers_Custom/Board/: board.c
  group Startup
    ../Core/Startup/: startup_stm32f407xx.s
  group StdPeriph_Driver
    ../Drivers/stdperiph/src/: stm32f4xx_rcc.c stm32f4xx_gpio.c stm32f4xx_usart.c misc.c stm32f4xx_tim.c stm32f4xx_iwdg.c
  group Speed_Feedback
    ../Algorithms/Speed/: speed_pi.c
    ../Algorithms/Encoder/: encoder_counter.c
    ../Drivers_Custom/Encoder/: encoder_hw.c
