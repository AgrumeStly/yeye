/** @file oled_pattern.c
 * @brief SSD1306页排列图样：8页，每页128列，每字节的8位从上至下表示像素。
 * 采用自包含5x7大写/数字字形，便于初学者查看，无动态内存或外部字体依赖。
 */
#include "oled_pattern.h"
#include <string.h>
static const char alphabet[]="0123456789ABCDEFGHIJKLMNOPQRSTUVWXYZ";
static const uint8_t font[][5]={
 {0x3e,0x51,0x49,0x45,0x3e},{0,0x42,0x7f,0x40,0},{0x42,0x61,0x51,0x49,0x46},
 {0x21,0x41,0x45,0x4b,0x31},{0x18,0x14,0x12,0x7f,0x10},{0x27,0x45,0x45,0x45,0x39},
 {0x3c,0x4a,0x49,0x49,0x30},{1,0x71,9,5,3},{0x36,0x49,0x49,0x49,0x36},
 {6,0x49,0x49,0x29,0x1e},{0x7e,0x11,0x11,0x11,0x7e},{0x7f,0x49,0x49,0x49,0x36},
 {0x3e,0x41,0x41,0x41,0x22},{0x7f,0x41,0x41,0x22,0x1c},{0x7f,0x49,0x49,0x49,0x41},
 {0x7f,9,9,9,1},{0x3e,0x41,0x49,0x49,0x7a},{0x7f,8,8,8,0x7f},{0,0x41,0x7f,0x41,0},
 {0x20,0x40,0x41,0x3f,1},{0x7f,8,0x14,0x22,0x41},{0x7f,0x40,0x40,0x40,0x40},
 {0x7f,2,0x0c,2,0x7f},{0x7f,4,8,0x10,0x7f},{0x3e,0x41,0x41,0x41,0x3e},
 {0x7f,9,9,9,6},{0x3e,0x41,0x51,0x21,0x5e},{0x7f,9,0x19,0x29,0x46},
 {0x46,0x49,0x49,0x49,0x31},{1,1,0x7f,1,1},{0x3f,0x40,0x40,0x40,0x3f},
 {0x1f,0x20,0x40,0x20,0x1f},{0x3f,0x40,0x38,0x40,0x3f},{0x63,0x14,8,0x14,0x63},
 {7,8,0x70,8,7},{0x61,0x51,0x49,0x45,0x43}};
/** @brief 在页中放置单行文字；page限0..7、每字6列，越过边框就截断。 */
static void text(uint8_t *buffer,uint32_t page,const char *s) {
    uint32_t column=4u,i,j;
    if (page>=8u) return;
    while (*s!=0 && column+5u<127u) {
        for (i=0u;i<36u;++i) if (alphabet[i]==*s) break;
        if (i<36u) for (j=0u;j<5u;++j) buffer[page*128u+column+j]=font[i][j];
        ++s; column+=6u;
    }
}
void oled_pattern_build(uint8_t *buffer,uint32_t phase,uint32_t seconds,uint8_t address) {
    uint32_t p,x,i; char line[]="TIME 0000 S";
    if (buffer==0) return;
    memset(buffer,0,1024u);
    if (phase<4u) {
        for (p=0u;p<8u;++p) for (x=0u;x<128u;++x)
            buffer[p*128u+x]=phase==0u ? 0xffu : phase==1u ? 0u :
                (uint8_t)(((x+(phase-2u)) & 1u)!=0u ? 0x55u : 0xaau);
        return;
    }
    text(buffer,1u,"OLED OK"); text(buffer,2u,"128X64 I2C");
    text(buffer,3u,address==0x3du ? "ADDR 3D" : "ADDR 3C");
    text(buffer,4u,"PB8 SCL  PB9 SDA");
    for (i=0u;i<4u;++i) { line[8u-i]=(char)('0'+seconds%10u); seconds/=10u; }
    text(buffer,6u,line);
    /* 一像素边框用于目视检查128列/64行完整性与列偏移；不覆盖文字区域。 */
    for (p=0u;p<8u;++p) { buffer[p*128u]=0xffu; buffer[p*128u+127u]=0xffu; }
    for (x=0u;x<128u;++x) { buffer[x]|=1u; buffer[896u+x]|=0x80u; }
}
