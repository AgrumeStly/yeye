# Keil uVision project yeye_control.uvprojx, settings and files
target LogicDemo (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(16000000) ELITTLE
  output: logic_demo +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F407xx
  c misc: --c99
  c include: .\include;.\vendor\cmsis;.\vendor\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x00080000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Application
    ./src/: main.c logic_demo.c car.c protocol.c
  group Board
    ./src/: board.c
  group Startup
    ./startup/: startup_stm32f407xx.s
target HardwareBench (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: as above
  output: yeye_control +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F407xx
  c misc: --c99
  c include: .\include;.\vendor\cmsis;.\vendor\stm32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x00080000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
